# Keil uVision project PMSM.uvprojx, settings and files
target Target 1 (6150000::V6.15::ARMCLANG)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.8.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: BLDC_FOC +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o ./bin/BLDC_FOC.bin ./Objects/BLDC_FOC.axf
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F405xx
  c include: ..\App\Inc;..\Driver\STM32F4\CMSIS;..\Driver\STM32F4\CORE\Inc;..\Driver\STM32F4\Inc;..\Bsp\TimerBase;..\Bsp\TimerPWM;..\Bsp\ADC;..\Bsp\IQmath;..\Bsp\Uart;..\Bsp\Can_Host;..\Service\Inc;..\Bsp\StFlash;..\Bsp\Eeprom;..\Bsp\Reangle_RS485;..\Service\SVPWM;..\Service\VVVF;..\Service\FOC;..\Service\MotorInfo;..\Bsp\CoderTama;..\Bsp\Dido
  memory RVCT4: ROM 0x80a1000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group App
    ../App/Src/: main.c Int_Ctrl.c MotorCmd_Ctrl.c RelayCmd_Ctrl.c HostState_Ctrl.c SensorCali_Ctrl.c Monitor.c
  group Service
    ../Service/Src/: HostProcess.c DataBaseProcess.c MODBusCRC.c RelayProcess.c
    ../Service/SVPWM/: SVPWM.c
    ../Service/VVVF/: VVVF.c
    ../Service/FOC/: Foc.c
    ../Service/MotorInfo/: MotorInfo.c
  group Bsp
    ../Bsp/TimerBase/: TimerBase.c
    ../Bsp/TimerPWM/: TimerPWM.c
    ../Bsp/ADC/: ADC.c
    ../Bsp/Can_Host/: Can_Host.c
    ../Bsp/Uart/: Uart.c
    ../Bsp/StFlash/: StFlash.c
    ../Bsp/IQmath/: AngleMath.c IQmathLib.lib
    ../Bsp/Eeprom/: Eeprom.c
    ../Bsp/Reangle_RS485/: ReangleRS485.c
    ../Bsp/CoderTama/: CoderTama.c
    ../Bsp/Dido/: Dido.c
  group Driver
    ../Driver/STM32F4/CMSIS/: startup_stm32f405xx.s
    ../Driver/STM32F4/CORE/Src/: stm32f4xx_hal_msp.c stm32f4xx_it.c system_stm32f4xx.c
    ../Driver/STM32F4/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_dfsdm.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dsi.c stm32f4xx_hal_eth.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_lptim.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_mmc.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_smbus.c stm32f4xx_hal_spdifrx.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_adc.c stm32f4xx_ll_crc.c stm32f4xx_ll_dac.c stm32f4xx_ll_dma.c stm32f4xx_ll_dma2d.c stm32f4xx_ll_exti.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_gpio.c stm32f4xx_ll_i2c.c stm32f4xx_ll_lptim.c stm32f4xx_ll_pwr.c stm32f4xx_ll_rcc.c stm32f4xx_ll_rng.c stm32f4xx_ll_rtc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_spi.c stm32f4xx_ll_tim.c stm32f4xx_ll_usart.c stm32f4xx_ll_utils.c
  group Doc
    ./: ReadMe.txt
